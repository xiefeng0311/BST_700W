# Keil uVision project RTT_750W_Chrg_CBT6_V0.0.1.uvprojx, settings and files
target RTT_750_Charger_v0.0.1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\RT-Thread_V3.1.3\components\finsh;..\RT-Thread_V3.1.3\include;..\RT-Thread_V3.1.3\include\libc;..\RT-Thread_V3.1.3\bsp;..\Dev;..\Dev\GPIO;..\Dev\timer;..\Dev\usart;..\Dev\led;..\Dev\ADC;..\Dev\CAN;..\Dev\PWM;..\Charger_Ctrl\h;..\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../RT-Thread_V3.1.3/bsp/: board.c rtconfig.h
  group Charger_Ctrl
    ../Charger_Ctrl/h/: Chrg_Ctrl.h
    ../Charger_Ctrl/c/: Chrg_Ctrl.c Temp_Ctrl.c
  group Dev
    ../Dev/ADC/: MCU_ADC.c MCU_ADC.h
    ../Dev/usart/: usart.c usart.h
    ../Dev/GPIO/: GPIO.c GPIO.h
    ../Dev/CAN/: CAN.c CAN.h
    ../Dev/led/: LED.c LED.h
    ../Dev/PWM/: PWM.c PWM.h
    ../Dev/timer/: drv_time.h drv_timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/: head.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group RT-Thread/Kernal
    ../RT-Thread_V3.1.3/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ./: device.c
  group RT-Thread/Ports
    ../RT-Thread_V3.1.3/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group RT-Thread/Finsh
    ../RT-Thread_V3.1.3/components/finsh/: cmd.c finsh.h finsh_api.h msh.c msh.h shell.c shell.h
  group README
    ../: README.TXT
